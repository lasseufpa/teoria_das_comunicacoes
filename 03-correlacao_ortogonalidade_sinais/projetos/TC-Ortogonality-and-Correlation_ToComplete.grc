options:
  parameters:
    author: mayron-pantoja
    generate_options: qt_gui
    id: Output
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: samp_rate/vec_length
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gabriel/Projects/GNU-Radio/files_dat/signal.dat
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    maximum: '5.0'
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: duration
    symbols: (0+0j, 0+0j, 0+0j)
    threshold: '0.99'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_corr_est_cc_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: duration
    symbols: (0+0j, 0+0j, 0+0j)
    threshold: '0.99'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0
    name: '"File"'
    size: samp_rate
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0
    name: '"Both Signals"'
    nconnections: '2'
    size: samp_rate
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,0
    name: '"Out A"'
    size: samp_rate
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 5,0
    name: '"Correlation A"'
    size: samp_rate
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 7,0
    name: '"Correlation B"'
    size: samp_rate
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 6,0
    name: '"Out B"'
    size: samp_rate
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '0'
  states: {state: disabled}

connections:
- [analog_sig_source_x_2, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_2, '0', blocks_float_to_complex_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0_1, '0']
- [blocks_float_to_complex_0, '0', digital_corr_est_cc_0, '0']
- [blocks_float_to_complex_0_0, '0', digital_corr_est_cc_0_0, '0']
- [blocks_throttle2_0_1, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_1_0_0_0_0_0_0_0, '0']
- [digital_corr_est_cc_0, '1', qtgui_time_sink_x_1_0_0_0_0_0_0_0_0, '0']
- [digital_corr_est_cc_0_0, '0', qtgui_time_sink_x_1_0_0_0_0_0_0_0_1, '0']
- [digital_corr_est_cc_0_0, '1', qtgui_time_sink_x_1_0_0_0_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
