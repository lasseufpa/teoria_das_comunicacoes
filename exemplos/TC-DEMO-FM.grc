options:
  parameters:
    author: gabriel
    generate_options: qt_gui
    id: TC-DEMO-FM
    output_language: python
    title: TC-DEMO-FM
  states: {}

blocks:
- name: Noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gabriel/Downloads/discpl/TD/hino_paisandu.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Before WBT"'
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_1, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
