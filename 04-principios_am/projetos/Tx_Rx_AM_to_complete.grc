options:
  parameters:
    author: mayron-pantoja
    generate_options: qt_gui
    id: Tx_Rx_AM_complete
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ar
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: constante_A
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: sr
  id: variable
  parameters:
    value: 2*882e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: float
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 805e3
    low_cutoff_freq: 795e3
    samp_rate: sr
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: ar
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\gabri\OneDrive\Documentos\Audacity\radioUFPA.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sr
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0
    name: '"Audio original"'
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sr
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,0
    name: '"Audio cortado"'
    type: float
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 5,0
    name: '"Audio recovered"'
    type: float
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 4,0
    name: '"Rx at position"'
    type: float
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sr
    fc: '0'
    fftsize: '4096'
    gui_hint: 2,0
    name: '"Transmissor"'
    type: float
    update_time: '0.010'
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(sr/ar)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(sr/samp_rate)
    interp: '1'
    type: fff
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', band_reject_filter_0, '0']
- [band_reject_filter_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
