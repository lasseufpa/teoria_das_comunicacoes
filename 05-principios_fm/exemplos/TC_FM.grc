options:
  parameters:
    author: gabriel
    generate_options: qt_gui
    id: TC_DEMO_FM
    output_language: python
    title: Demo-FM
  states: {}

blocks:
- name: FM_chooser
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,11
    label: FM-chooser
    min_len: '10'
    rangeType: int
    start: '85000000'
    step: '50000'
    stop: '110000000'
    value: '93700000'
  states: {}
- name: FM_chooser_Tx
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:0,0,1,11
    label: FM-chooser2
    min_len: '10'
    rangeType: int
    start: '85000000'
    step: '50000'
    stop: '110000000'
    value: '90000000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: down_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,9,1,1
    label: RF Gain
    min_len: '10'
    start: '10'
    step: '5'
    stop: '100'
    value: '100'
    widget: dial
  states: {}
- name: rfgain2
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:1,0,1,1
    label: RF Gain
    min_len: '10'
    start: '10'
    step: '5'
    stop: '100'
    value: '10'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,10,1,1
    label: Volume
    min_len: '10'
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: dial
  states: {}
- name: volume2
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:1,1,1,1
    label: Volume
    min_len: '10'
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: down_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 5*audio_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume2/100
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gabriel/Repositorios/teoria_das_comunicacoes/01-apresentacao_curso_e_conceitos_fundamentais/exemplos/hino_paysandu.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: int(samp_rate/down_rate)
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: down_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:2,9,1,2
    name: '"Demodulated"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate2
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:2,0,1,2
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    rate: '15'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 2e6
    fc: FM_chooser
    fftsize: '4096'
    gui_hint: tabs@0:1,0,2,9
    name: '"Sampling Bandpass"'
    plotconst: 'False'
    rate: '15'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: 2e6
    fc: FM_chooser
    fftsize: '4096'
    gui_hint: tabs@0:3,0,1,5
    name: '"Sampling Bandpass"'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '15'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: 2e6
    fc: FM_chooser
    fftsize: '4096'
    gui_hint: tabs@0:3,6,1,5
    name: '"Sampling Bandpass"'
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    rate: '15'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: audio_rate*10
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:1,2,2,9
    name: '"Before transmit"'
    plotconst: 'False'
    rate: '50'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate*10
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:3,0,1,5
    name: '"Before transmit"'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '15'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_1
  id: qtgui_sink_x
  parameters:
    bw: audio_rate*10
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:3,6,1,5
    name: '"Before transmit"'
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    rate: '15'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '24'
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: ReceptorFM
    label1: TransmissorFM
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: FM_chooser_Tx
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: '"serial=3180E74"'
    dev_args: '""'
    gain0: rfgain2
    len_tag_name: ''
    samp_rate: samp_rate2
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: FM_chooser
    clock_rate: '0.0'
    dev_addr: '"serial=EFR14UDB1"'
    dev_args: '""'
    gain0: rfgain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_1, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_1_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_1_1, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0_0_0, '0', qtgui_sink_x_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', qtgui_sink_x_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
